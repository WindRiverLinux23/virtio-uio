EXTRA_OECONF_append_euto-v9-discovery = " --enable-video-wayland"
PACKAGECONFIG[opengl] = "--enable-video-opengl,--disable-video-opengl,virtual/libgles1"
